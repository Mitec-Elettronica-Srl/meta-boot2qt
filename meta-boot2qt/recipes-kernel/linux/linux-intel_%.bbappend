SRC_URI += "\
    file://fragment.cfg \
    file://fragment.scc \
"
