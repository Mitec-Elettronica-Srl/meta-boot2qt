
PACKAGECONFIG += "flite"
