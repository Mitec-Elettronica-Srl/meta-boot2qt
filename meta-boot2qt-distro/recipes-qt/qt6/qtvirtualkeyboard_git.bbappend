
PACKAGECONFIG:append = " hunspell"
RDEPENDS:${PN} += "hunspell-dicts"
