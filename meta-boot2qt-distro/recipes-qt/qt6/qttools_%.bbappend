PACKAGECONFIG:remove:class-target = "clang"
