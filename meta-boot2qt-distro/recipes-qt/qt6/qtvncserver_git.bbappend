
DEPENDS += "libtomcrypt"
