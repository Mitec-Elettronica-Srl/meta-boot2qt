
# build avahi without GTK UI
AVAHI_GTK = ""
