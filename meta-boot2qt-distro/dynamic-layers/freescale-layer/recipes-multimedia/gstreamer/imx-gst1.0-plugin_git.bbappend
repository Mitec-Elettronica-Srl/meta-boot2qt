DEPENDS:append:mx93-nxp-bsp = " libdrm"
