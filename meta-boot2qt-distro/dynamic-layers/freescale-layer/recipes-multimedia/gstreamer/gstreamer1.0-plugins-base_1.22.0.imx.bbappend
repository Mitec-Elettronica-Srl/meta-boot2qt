PACKAGECONFIG:remove:mx93-nxp-bsp = "viv-fb"
