FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-imx93-expand-kernel-image-load-space.patch"

