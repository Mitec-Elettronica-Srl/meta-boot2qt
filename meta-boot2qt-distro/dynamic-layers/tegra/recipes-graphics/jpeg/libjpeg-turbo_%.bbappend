
# Enable v8 API
EXTRA_OECONF:append:class-target = " --with-jpeg8"
