# tegra-firmware linux-firmware have conflicting files
RDEPENDS:${PN}:remove = "linux-firmware"
