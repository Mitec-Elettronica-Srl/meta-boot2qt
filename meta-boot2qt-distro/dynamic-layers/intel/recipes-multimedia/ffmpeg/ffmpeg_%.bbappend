
PACKAGECONFIG:append = " vaapi"
RRECOMMENDS:${PN} += "intel-vaapi-driver"
