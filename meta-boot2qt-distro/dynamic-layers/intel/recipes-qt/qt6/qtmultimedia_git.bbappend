
PACKAGECONFIG += "vaapi"
