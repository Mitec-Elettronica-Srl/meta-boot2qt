FILESEXTRAPATHS:append := "${THISDIR}/gcc:"
SRC_URI += "\
    file://0001-mingw-use-UCRT-instead-msvcrt.patch \
"
