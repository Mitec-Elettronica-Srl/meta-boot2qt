
PACKAGECONFIG:remove = "libjitterentropy"
