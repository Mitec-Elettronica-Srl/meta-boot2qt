
PACKAGECONFIG:append = " openssl "
