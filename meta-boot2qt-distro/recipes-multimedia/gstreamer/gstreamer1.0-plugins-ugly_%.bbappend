
PACKAGECONFIG:append = " x264"
FILES:${PN}-x264 += "${datadir}/gstreamer-1.0/presets/*.prs"
